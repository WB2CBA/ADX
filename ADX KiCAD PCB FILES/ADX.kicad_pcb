# Repository WB2CBA/ADX

File README.md:

ADX - Arduino Digital Modes Transceiver UPDATE (02 June 2025):

FOR CAT CONTROL try using KENWOOD TS-440S or KENWOOD TS-140S. HAMLIB in WSJTX has an error in CAT Control for TS-2000 in WSJTX V2.7 or later.It doesn't work. This has nothing to do with ADX CAT Control Routine.
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
ADX - Arduino Digital Modes Transceiver UPDATE (14 July 2023):

- Cowtown Amateur Radio Club ADX Buildathon Construction Manual added.

- I can't thank enough to Richard Hinsley, W5ARH/VK2ARH for putting together this detailed and extremely well put together build manual. 

- ADX Build Manual V1.5 Released.(10 June 2023)

- Calibration Procedure Changed to protect EEPROM from R/W wear out during calibration. (20 December 2022) 

- Caution Note on SI5351 Library.

- ZENER DIODE PA MOSFET PROTECTION to protect PA Mosfets from excessive SWR conditions.(20 December 2022)

- ADX_CAT_V1.6 - Band display bug corrections. Release Date: 14 July 2023  I would like to thank Peter Petrov, LA7WRA and Mark Culross, KD5RXT for spotting this rather embarrasing bug on my part.

-   Firmware release with CAT Control serial baud rate changed to 9600 bps to address problems on TS2000  CAT control on WSJT/X (Hamlib) with 115200 bps. Also excellent code structuring and cleanup  thanks to Joerg Frede,DK3JF. 

- I also added .hex files into ADX Firmware folder. These .hex files can be uploaded to atmega328p microcontroller via ISP port using a programmer like usbasp. 

- These .hex can be used to upload ADX firmware without using Arduino ide and compiling.

- SI5351 Module pull up resistor fix update added to Build Manual V1.4 (08 April 2023)

IMPORTANT NOTE ON NT7S SI5351 LIBRARY VERSIONS   

Please install SI5351 Library that is in ADX Github under ADX Firmware! 
Or use Etherkit SI5351 Library Version 2.1.3. 
ADX firmware is compatible with only Etherkit SI5351 Library version 2.1.3.
____________________________________________________________________________

ADX is an Arduino based Digital Modes Transceiver.

- ADX - is abbreviation for Arduino Digital Xceiver.

- ADX is a mono band (actually quad band) digital modes optimized HF transceiver that can cover four pre-programmed bands one band at a time by swapping Band LPF Modules. 
It can work on 80m, 40m, 30m,20m, 17m, 15m and 10m bands and can operate on four of the most popular digital modes, FT8, FT4, JS8call and WSPR.

- ADX now supports CAT via emulating KENWOOD TS2000 HF Transceiver with 9600 bps,8,1 Serial comm. CAT controls Band and Mode changes.

My goal with this project is to design a simple HF Transceiver optimized for operating on Digital modes:
-	Simple to procure – meaning not effected by chip shortage
-	Simple to build – 2 modules, 2 IC’s and 4 Mosfets!
-	Simple to setup and tune – One simple calibration procedure is all needed.
-	Simple to operate – Plug in ADX MIC to soundcard MIC input and ADX SPK to PC soundcard speaker input and we are good to go with any digital modes Software.
-	Dirt Cheap – Costs less than 25$ to get all parts and PCB if we exclude ridiculous shipping costs!

- Plug in a USB cable between ADX Arduino and your PC, Select Kenwood TS2000 with 9600bps,8,1 setup as your CAT rig and you will have CAT control on ADX!

- For ease of following which parts to solder while building Main board of ADX, Interactive BOM File - ibom_ADX.html file is a great help. Just run that file on Microsoft edge and follow each highlighted component and solder one by one. This interactive BOM was prepared by Gilles DELPECH - F1BFU. Thank you Gilles!

If you like my designs and would like to support my work:
https://www.buymeacoffee.com/wb2cba

## KiCad design ADX KiCAD PCB FILES/ADX.kicad_pcb

Parts:
C1, C16, C24: 100uF/16V; CP_Radial_D5.0mm_P2.50mm
C2, C3, C6, C8, C9, C10, C14, C15, C19, C20, C21, C22, C23: 100nF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C4, C5: 10nF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C7: 470nF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C11: 620pF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C12, C17: 10nF; C_Disc_D3.0mm_W2.0mm_P2.50mm
C13, C18: 10uF/16V; CP_Radial_D5.0mm_P2.50mm
CON1: SPK; Headphone_Jack_3.5mm_SJ1-3523N; MPN SJ1-3523N; Digi-Key_PN CP1-3523N-ND
CON2: MIC; Headphone_Jack_3.5mm_SJ1-3523N; MPN SJ1-3523N; Digi-Key_PN CP1-3523N-ND
CX1: C_Disc_D3.0mm_W1.6mm_P2.50mm
D1: TX; LED_D3.0mm
D2: FT8; LED_D3.0mm
D3: FT4; LED_D3.0mm
D4: JS8; LED_D3.0mm
D5: WSPR; LED_D3.0mm
D6: 1N4148; D_A-405_P2.54mm_Vertical_AnodeUp
D7, D8: 1N4148; D_A-405_P2.54mm_Vertical_KathodeUp
D9: 1N5817; D_A-405_P2.54mm_Vertical_KathodeUp
GND1: TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_ISO7380_Pad
J1: SMA; SMA_Samtec_SMA-J-P-X-ST-EM1_EdgeMount
J1A1: BNC; BNC_Amphenol_B6252HB-NPP3G-50_Horizontal
J2: PJ-102A; Barrel_Jack_5.5mmODx2.1mmID_PJ-102A; MPN PJ-102A; Digi-Key_PN CP-102A-ND
L1: 1uH; L_Toroid_Vertical_L10.0mm_W5.0mm_P5.08mm
L2: 100uH; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
Q1, Q2, Q3: BS170; TO-92_HandSolder; MPN BS170; Digi-Key_PN BS170-ND
Q4: BS170; TO-92L_HandSolder; MPN BS170; Digi-Key_PN BS170-ND
R1: 1M; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R2: 4.7k; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R3, R4, R10, R11, R15: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R5, R6, R7, R8, R9, R13: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R12: 2.7k; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R14: 100; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
SW1: UP(BAND); SW_PUSH_6mm
SW2: DOWN(CAL); SW_PUSH_6mm
SW3: TX; SW_PUSH_6mm
TP1: CLK0; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
TP2: CLK1; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
TP3, TP4: TestPoint; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
TP7: GND; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
TP8: CAL; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
TP_D1: TestPoint_THTPad_1.0x1.0mm_Drill0.5mm
TP_G1: TestPoint_THTPad_1.0x1.0mm_Drill0.5mm
TP_S1: TestPoint_THTPad_1.0x1.0mm_Drill0.5mm
U1: CD2003GB_GP; DIP-16_W7.62mm_Socket_LongPads
U2: SI535X_Module; SI5351 Module_Vertical
U3: 74ACT244; DIP-20_W7.62mm_LongPads
U4: uSDX_LPF_BAND_MODULE; uSDX_LPF_Band_Module
XA1: Arduino_Nano_Socket

Connections:
+3.3V: R1.1, XA1.3V3 (3.3V)
+5V: C1.1, C2.1, C15.1, C16.1, C23.1, L2.1, R10.1, R11.1, R15.1, U2.1 (VIN), U3.20 (VCC), XA1.5V
+12V: C18.1, C19.1, C20.1, C24.1, D9.1 (K), U4.1 (+12V), XA1.VIN
FSK: C5.1, R4.2, XA1.D7
GNDPWR: C1.2, C2.2, C4.2, C5.2, C6.2, C8.1, C9.1, C10.1, C12.2, C13.2, C14.2, C15.2, C16.2, C18.2, C19.2, C20.2, C23.2, C24.2, CON1.1 (S), CON2.1 (S), D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.2 (A), GND1.1, H1.1, H2.1, H3.1, H4.1, J1.2 (Ext), J1A1.2 (Ext), J2.2, Q1.3 (S), Q2.3 (S), Q3.3 (S), R2.2, R12.2, R13.2, SW1.1, SW2.1, SW3.1, TP7.1, U1.1, U1.2, U1.5, U1.9, U2.2 (GND), U3.1 (OEa), U3.10 (GND), U3.19 (OEb), U4.4 (GND), U4.7 (GND), U4.8 (GND), XA1.D6, XA1.GND1 (GND), XA1.GND2 (GND)
unnamed: C3.1, R1.2, R2.1, R3.1
unnamed: C3.2, CON1.2 (T), CON1.3 (R)
unnamed: C4.1, R3.2, R4.1
unnamed: C6.1, C7.1, CON2.2 (T), CON2.3 (R)
unnamed: C10.2, U1.14
unnamed: C11.1, Q4.3 (S), R13.1, TP_S1.1
unnamed: C11.2, CX1.1, D7.1 (K), D8.2 (A), L1.1, U1.16
unnamed: C8.2, C9.2, C13.1, C14.1, CX1.2, D7.2 (A), D8.1 (K), L1.2, L2.2, R14.2, U1.6, U1.7, U1.15
unnamed: C17.1, Q4.1 (D), TP_D1.1
unnamed: C21.1, R14.1, U1.12
unnamed: C22.1, D6.1 (K), Q1.2 (G), Q2.2 (G), Q3.2 (G), R12.1
unnamed: C22.2, U3.3 (O3b), U3.5 (O2b), U3.7 (O1b), U3.9 (O0b), U3.12 (O3a), U3.14 (O2a), U3.16 (O1a), U3.18 (O0a)
unnamed: D1.2 (A), R5.2
unnamed: D2.2 (A), R6.2
unnamed: D3.2 (A), R7.2
unnamed: D4.2 (A), R8.2
unnamed: D5.2 (A), R9.2
unnamed: D9.2 (A), J2.1
unnamed: J1.1 (In), J1A1.1 (In), TP4.1, U4.5 (ANT1), U4.6 (ANT2)
unnamed: R5.1, XA1.D13 (D13_SCK)
unnamed: R6.1, XA1.D12 (D12_MISO)
unnamed: R7.1, XA1.D11 (D11_MOSI)
unnamed: R8.1, XA1.D10 (D10_CS)
unnamed: R9.1, XA1.D9
unnamed: TP1.1, U2.7 (SO), U3.2 (I0a), U3.4 (I1a), U3.6 (I2a), U3.8 (I3a), U3.11 (I0b), U3.13 (I1b), U3.15 (I2b), U3.17 (I3b)
unnamed: TP8.1, U2.5 (S2)
RX: C17.2, U4.3 (RD)
RXA: C7.2, U1.4
RXSW: C12.1, Q4.2 (G), TP_G1.1, XA1.D8
RX_OSC: C21.2, TP2.1, U2.6 (S1)
SCL: U2.4 (SCL), XA1.A5 (A5_SCL)
SDA: U2.3 (SDA), XA1.A4 (A4_SDA)
SW1: R10.2, SW1.2, XA1.D2 (D2_INT0)
SW2: R11.2, SW2.2, XA1.D3 (D3_INT1)
SW3: R15.2, SW3.2, XA1.D4
TD_IN: Q1.1 (D), Q2.1 (D), Q3.1 (D), TP3.1, U4.2 (TD)

Board: 2 copper layers, 97.1 x 97.0 mm, 82 parts (8 on the bottom side), 41 nets.

File ADX QUAD BOM.xlsx:

Part | Designator | Footprint
100uF/16V | C1,C16,C24 | Capacitor_THT:CP_Radial_D5.0mm_P2.50mm
620pF | C11 | Capacitor_THT:C_Disc_D3.0mm_W1.6mm_P2.50mm
10nF | C12,C17 | Capacitor_THT:C_Disc_D3.0mm_W2.0mm_P2.50mm
10uF/16V | C13,C18 | Capacitor_THT:CP_Radial_D5.0mm_P2.50mm
100nF | C2,C3,C6,C8,C9,C10,C14,C15,C19,C20,C21,C22,C23 | Capacitor_THT:C_Disc_D3.0mm_W1.6mm_P2.50mm
10nF | C4,C5 | Capacitor_THT:C_Disc_D3.0mm_W1.6mm_P2.50mm
470nF | C7 | Capacitor_THT:C_Disc_D3.0mm_W1.6mm_P2.50mm
SPK | CON1 | digikey-footprints:Headphone_Jack_3.5mm_SJ1-3523N
MIC | CON2 | digikey-footprints:Headphone_Jack_3.5mm_SJ1-3523N
TX | D1 | LED_THT:LED_D3.0mm
FT8 | D2 | LED_THT:LED_D3.0mm
FT4 | D3 | LED_THT:LED_D3.0mm
JS8 | D4 | LED_THT:LED_D3.0mm
WSPR | D5 | LED_THT:LED_D3.0mm
1N4148 | D6 | Diode_THT:D_A-405_P2.54mm_Vertical_AnodeUp
1N4148 | D7,D8 | Diode_THT:D_A-405_P2.54mm_Vertical_KathodeUp
1N5817 | D9 | Diode_THT:D_A-405_P2.54mm_Vertical_KathodeUp
SMA | J1 | SMA_EDGE:SMA_Samtec_SMA-J-P-X-ST-EM1_EdgeMount
BNC | J1A1 | Connector_Coaxial:BNC_Amphenol_B6252HB-NPP3G-50_Horizontal
PJ-102A | J2 | digikey-footprints:Barrel_Jack_5.5mmODx2.1mmID_PJ-102A
1uH | L1 | Inductor_THT:L_Toroid_Vertical_L10.0mm_W5.0mm_P5.08mm
100uH | L2 | Resistor_THT:R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
BS170 | Q1,Q2,Q3 | Package_TO_SOT_THT:TO-92_HandSolder
BS170 | Q4 | Package_TO_SOT_THT:TO-92L_HandSolder
1M | R1 | Resistor_THT:R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
2.7k | R12 | Resistor_THT:R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
100 | R14 | Resistor_THT:R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
4.7k | R2 | Resistor_THT:R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
10k | R3,R4,R10,R11,R15 | Resistor_THT:R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
1k | R5,R6,R7,R8,R9,R13 | Resistor_THT:R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
UP(BAND) | SW1 | Button_Switch_THT:SW_PUSH_6mm
DOWN(CAL) | SW2 | Button_Switch_THT:SW_PUSH_6mm
TX | SW3 | Button_Switch_THT:SW_PUSH_6mm
CD2003GB_GP | U1 | Package_DIP:DIP-16_W7.62mm_Socket_LongPads
SI5351_Module | U2 | VFO_footprint:SI5351 Module_Vertical
74ACT244 | U3 | Package_DIP:DIP-20_W7.62mm_LongPads
uSDX_LPF_BAND_MODULE | U4 | uSDX_LPF_BAND_MODULE:uSDX_mOnO LPF_Band_Module
Arduino_Nano_Socket | XA1 | Arduino:Arduino_Nano

## Commit log

2022-04-16 Create ...
2023-04-29 code cleanup to make it more readable
2023-06-09 Fix transmit on wrong frequency
